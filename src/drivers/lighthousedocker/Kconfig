## src/drivers/lighthousedocker/Kconfig
```kconfig
menuconfig DRIVERS_LIGHTHOUSEDOCKER
	bool "lighthousedocker"
	default n
	---help---
		Enable support for lighthousedocker
```
